<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Shuttle_Wifi.ewp</path>
  </project>
  <batchBuild />
</workspace>
